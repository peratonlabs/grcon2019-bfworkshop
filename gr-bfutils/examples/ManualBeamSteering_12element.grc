options:
  parameters:
    generate_options: qt_gui
    id: ManualBeamSteering
    output_language: python
    title: Manual Beam Steering
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    precision: '8'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: qpsk
  states: {}
- name: constel_intf
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    precision: '8'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: 16qam
  states: {}
- name: intf_angle
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Interferer Angle
    orient: Qt.Horizontal
    start: '-180.0'
    step: '0.01'
    stop: '180.0'
    value: '45.0'
  states: {}
- name: intf_voltage
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Interferer Voltage
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: 'Channel: Noise Voltage'
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: num_streams
  id: variable
  parameters:
    value: '12'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: soi_voltage
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Source Voltage
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.9'
  states: {}
- name: source_angle
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Source Angle
    orient: Qt.Horizontal
    start: '-180.0'
    step: '0.01'
    stop: '180.0'
    value: '0.0'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: steering_angle
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Beamsteering Angle
    orient: Qt.Horizontal
    start: '-180.0'
    step: '0.01'
    stop: '180.0'
    value: '90.0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '200'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '200'
    repeat: 'True'
    type: byte
  states: {}
- name: bfutils_manual_beamsteering_0
  id: bfutils_manual_beamsteering
  parameters:
    angle_degrees: steering_angle
    num_elements: num_streams
    sep_lambda: '0.5'
  states: {}
- name: bfutils_polar_plot_0
  id: bfutils_polar_plot
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,1,1
    log_scale: 'True'
    plot_depth: '70.0'
  states: {}
- name: bfutils_ula_sim_0
  id: bfutils_ula_sim
  parameters:
    angle_degrees: source_angle
    log_response: 'True'
    num_elements: num_streams
    sep_lambda: '0.5'
  states: {}
- name: bfutils_ula_sim_0_0
  id: bfutils_ula_sim
  parameters:
    angle_degrees: intf_angle
    log_response: 'True'
    num_elements: num_streams
    sep_lambda: '0.5'
  states: {}
- name: bfutils_weights_to_matrix_a_0
  id: bfutils_weights_to_matrix_a
  parameters: {}
  states: {}
- name: bfutils_weights_to_plot_0
  id: bfutils_weights_to_plot
  parameters:
    log_response: 'True'
    num_elements: num_streams
    sep_lambda: '0.5'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: num_streams
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: intf_voltage
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: soi_voltage
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: ((1+0j, 0+0j, 0+0j, 0+0j,0+0j, 0+0j, 0+0j,0+0j, 0+0j, 0+0j,0+0j, 0+0j,),)
    comment: |-
      Apply the weights to
       just the preamble 
      to beamform down 
      to a single stream
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: num_streams
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_volt
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel_intf
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from cmath import exp, pi
  states: {}
- name: import_cmath
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_auto
  id: note
  parameters:
    note: auto-build LUT
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,1,1,1
    name: ''
    size: '1024'
    type: complex
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [analog_random_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [bfutils_manual_beamsteering_0, weights, bfutils_weights_to_matrix_a_0, weights]
- [bfutils_manual_beamsteering_0, weights, bfutils_weights_to_plot_0, weights]
- [bfutils_ula_sim_0, '0', blocks_add_xx_0, '0']
- [bfutils_ula_sim_0_0, '0', blocks_add_xx_0, '1']
- [bfutils_weights_to_matrix_a_0, A, blocks_multiply_matrix_xx_0, set_A]
- [bfutils_weights_to_plot_0, plot, bfutils_polar_plot_0, plot]
- [blocks_add_xx_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_multiply_const_vxx_0, '0', bfutils_ula_sim_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', bfutils_ula_sim_0, '0']
- [blocks_multiply_matrix_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_throttle_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_multiply_matrix_xx_0, '1']
- [blocks_vector_to_streams_0, '10', blocks_multiply_matrix_xx_0, '10']
- [blocks_vector_to_streams_0, '11', blocks_multiply_matrix_xx_0, '11']
- [blocks_vector_to_streams_0, '2', blocks_multiply_matrix_xx_0, '2']
- [blocks_vector_to_streams_0, '3', blocks_multiply_matrix_xx_0, '3']
- [blocks_vector_to_streams_0, '4', blocks_multiply_matrix_xx_0, '4']
- [blocks_vector_to_streams_0, '5', blocks_multiply_matrix_xx_0, '5']
- [blocks_vector_to_streams_0, '6', blocks_multiply_matrix_xx_0, '6']
- [blocks_vector_to_streams_0, '7', blocks_multiply_matrix_xx_0, '7']
- [blocks_vector_to_streams_0, '8', blocks_multiply_matrix_xx_0, '8']
- [blocks_vector_to_streams_0, '9', blocks_multiply_matrix_xx_0, '9']
- [channels_channel_model_0, '0', qtgui_const_sink_x_1, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
