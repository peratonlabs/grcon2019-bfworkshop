options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: InterferenceNulling
    output_language: python
    title: Interference Nulling
  states: {}

blocks:
- name: angle
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: ULA Angle
    orient: Qt.Horizontal
    start: '-90'
    step: '.1'
    stop: '90'
    value: '45'
  states: {}
- name: bb_filter
  id: variable
  parameters:
    value: firdes.root_raised_cosine(sps, sps, 1, eb, 101)
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[1,-1]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0,1]'
    type: qpsk
  states: {}
- name: constel_intf
  id: variable_constellation
  parameters:
    const_points: '[1,-1]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0,1]'
    type: 8psk
  states: {}
- name: data
  id: variable
  parameters:
    value: '[0]*4+[random.getrandbits(8) for i in range(payload_size)]'
  states: {}
- name: data_2
  id: variable
  parameters:
    value: '[0]*4+[random.getrandbits(8) for i in range(payload_size)]'
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: gap
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: intf_angle
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,1
    label: Interferer Angle
    orient: Qt.Horizontal
    start: '-90'
    step: '.1'
    stop: '90'
    value: '75'
  states: {}
- name: matched_filter
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1, eb, int(11*sps*nfilts))
  states: {}
- name: modulated_sync_word
  id: variable
  parameters:
    value: modulated_sync_word_pre[86:(86+512)]
  states: {}
- name: modulated_sync_word_2
  id: variable
  parameters:
    value: modulated_sync_word_pre_2[86:(86+512)]
  states: {}
- name: modulated_sync_word_pre
  id: variable_modulate_vector
  parameters:
    data: ' preamble'
    mod: rxmod
    taps: '[1]'
  states: {}
- name: modulated_sync_word_pre_2
  id: variable_modulate_vector
  parameters:
    data: ' preamble_2'
    mod: rxmod_2
    taps: '[1]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Noise
    orient: Qt.Horizontal
    start: '0'
    step: '0.005'
    stop: '10'
    value: '.1'
    widget: slider
  states: {}
- name: noise_angle
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Noise Angle
    orient: Qt.Horizontal
    start: '-90'
    step: '.1'
    stop: '90'
    value: '15'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '992'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0x27,0x2F,0x18,0x5D,0x5B,0x2A,0x3F,0x71,0x63,0x3C,0x17,0x0C,0x0A,0x41,0xD6,0x1F,0x4C,0x23,0x65,0x68,0xED,0x1C,0x77,0xA7,0x0E,0x0A,0x9E,0x47,0x82,0xA4,0x57,0x24,]'
  states: {}
- name: preamble_2
  id: variable
  parameters:
    value: '[0xC4,0x5E,0x82,0x06,0x92,0xE2,0xA4,0x05,0xE1,0xE3,0x47,0x57,0x6D,0xAC,0xAC,0xD7,0x44,0xD8,0x65,0x44,0x91,0x0A,0x17,0x04,0x85,0x0D,0x93,0xDF,0xEA,0x0B,0x8C,0xDC,]'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), eb, 5*sps*nfilts)
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(constel, False, sps, True, eb, False, False)
  states: {}
- name: rxmod_2
  id: variable
  parameters:
    value: digital.generic_mod(constel_intf, False, sps, True, eb, False, False)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: soi
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,1,1,1
    label: SOI Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.005'
    stop: '1.0'
    value: '0.1'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_fastnoise_source_x_0_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: bfutils_interference_nulling_0
  id: bfutils_interference_nulling
  parameters:
    nulling_dims: '1'
    num_elements: '4'
  states: {}
- name: bfutils_preamble_to_pdu_0
  id: bfutils_preamble_to_pdu
  parameters:
    corr_tag: '"corr_est"'
    data_length: len(modulated_sync_word_2)
    num_elements: '4'
  states: {}
- name: bfutils_ula_sim_0
  id: bfutils_ula_sim
  parameters:
    angle_degrees: angle
    log_response: 'True'
    num_elements: '4'
    sep_lambda: '0.5'
  states: {}
- name: bfutils_ula_sim_1
  id: bfutils_ula_sim
  parameters:
    angle_degrees: intf_angle
    log_response: 'True'
    num_elements: '4'
    sep_lambda: '0.5'
  states: {}
- name: bfutils_ula_sim_1_0
  id: bfutils_ula_sim
  parameters:
    angle_degrees: noise_angle
    log_response: 'True'
    num_elements: '4'
    sep_lambda: '0.5'
  states: {}
- name: bfutils_weights_to_matrix_a_0
  id: bfutils_weights_to_matrix_a
  parameters: {}
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
    vlen: '4'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: len(modulated_sync_word_pre)
  states: {state: disabled}
- name: blocks_complex_to_mag_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: len(modulated_sync_word_2)
    num_ports: '3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: soi
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: ((1+0j, 0+0j, 0+0j, 0+0j),(0+0j,1+0j, 0+0j, 0+0j),(0+0j, 0+0j,1+0j, 0+0j),)
    comment: |-
      Apply the weights to
      project into the null space
      of the interferer
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: ((len(preamble)+len(data))*4*sps, gap)
    type: complex
  states: {}
- name: blocks_stream_mux_0_0_0
  id: blocks_stream_mux
  parameters:
    lengths: ((len(preamble)+len(data))*4*sps, gap)
    type: complex
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: modulated_sync_word_pre
    vlen: len(modulated_sync_word_pre)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: preamble+data
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Strong interferer
    repeat: 'True'
    type: byte
    vector: preamble_2+data_2
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'False'
    excess_bw: eb
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel_intf
    differential: 'False'
    excess_bw: eb
    samples_per_symbol: sps
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    comment: |-
      Correlate against the preamble
      of the interferer
    mark_delay: '1'
    sps: sps
    symbols: modulated_sync_word_2
    threshold: '0.8'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_corr_est_cc_0_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: sps
    symbols: modulated_sync_word
    threshold: '.1'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_corr_est_cc_0_1
  id: digital_corr_est_cc
  parameters:
    comment: |-
      In the presence of the strong interferer,
      the correlation with the preamble 
      of the source doesn't show any peaks
    mark_delay: '1'
    sps: sps
    symbols: modulated_sync_word
    threshold: '0.8'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1,0,1,2
    name: Correlation After Null Space Projection
    size: '102400'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,1,2
    name: Correlation Before Null Space Projection
    size: '102400'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,0,5,1
    marker1: '0'
    name: Eigenvalues
    srate: samp_rate
    stemplot: 'True'
    type: msg_float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: 12,0,1,1
    name: Modulated Sync Word
    vlen: len(modulated_sync_word_pre)
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}

connections:
- [analog_fastnoise_source_x_0_0, '0', bfutils_ula_sim_1_0, '0']
- [bfutils_interference_nulling_0, eigenvalues, qtgui_time_sink_x_1, in]
- [bfutils_interference_nulling_0, weights, bfutils_weights_to_matrix_a_0, weights]
- [bfutils_preamble_to_pdu_0, pdus, bfutils_interference_nulling_0, pdus]
- [bfutils_ula_sim_0, '0', blocks_add_xx_0, '0']
- [bfutils_ula_sim_1, '0', blocks_add_xx_0, '1']
- [bfutils_ula_sim_1_0, '0', blocks_add_xx_0, '2']
- [bfutils_weights_to_matrix_a_0, A, blocks_multiply_matrix_xx_0, set_A]
- [blocks_add_xx_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_mag_0_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_delay_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_delay_0, '1', blocks_streams_to_vector_0, '2']
- [blocks_delay_0, '2', blocks_streams_to_vector_0, '3']
- [blocks_multiply_const_vxx_0, '0', bfutils_ula_sim_0, '0']
- [blocks_multiply_matrix_xx_0, '0', digital_corr_est_cc_0_0, '0']
- [blocks_multiply_matrix_xx_0, '1', blocks_null_sink_0_0, '0']
- [blocks_multiply_matrix_xx_0, '2', blocks_null_sink_0_0, '1']
- [blocks_null_source_0_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_null_source_0_0_0, '0', blocks_stream_mux_0_0_0, '1']
- [blocks_stream_mux_0_0, '0', blocks_throttle_0, '0']
- [blocks_stream_mux_0_0_0, '0', bfutils_ula_sim_1, '0']
- [blocks_streams_to_vector_0, '0', bfutils_preamble_to_pdu_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_vector_source_x_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_source_x_0_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_vector_to_streams_0, '0', digital_corr_est_cc_0, '0']
- [blocks_vector_to_streams_0, '0', digital_corr_est_cc_0_1, '0']
- [blocks_vector_to_streams_0, '1', blocks_delay_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_multiply_matrix_xx_0, '1']
- [blocks_vector_to_streams_0, '2', blocks_delay_0, '1']
- [blocks_vector_to_streams_0, '2', blocks_multiply_matrix_xx_0, '2']
- [blocks_vector_to_streams_0, '3', blocks_delay_0, '2']
- [blocks_vector_to_streams_0, '3', blocks_multiply_matrix_xx_0, '3']
- [digital_constellation_modulator_0, '0', blocks_stream_mux_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_stream_mux_0_0_0, '0']
- [digital_corr_est_cc_0, '0', blocks_streams_to_vector_0, '0']
- [digital_corr_est_cc_0_0, '0', blocks_null_sink_1_0, '0']
- [digital_corr_est_cc_0_0, '1', blocks_complex_to_mag_0, '0']
- [digital_corr_est_cc_0_1, '0', blocks_null_sink_1, '0']
- [digital_corr_est_cc_0_1, '1', blocks_complex_to_mag_0_1, '0']

metadata:
  file_format: 1
