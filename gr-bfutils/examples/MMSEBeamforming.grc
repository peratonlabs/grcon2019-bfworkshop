options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: MMSEBeamforming
    output_language: python
    title: MMSE Beamforming
  states: {}

blocks:
- name: angle
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: ULA Angle
    orient: Qt.Horizontal
    start: '-90'
    step: '.1'
    stop: '90'
    value: '45'
  states: {}
- name: bb_filter
  id: variable
  parameters:
    value: firdes.root_raised_cosine(sps, sps, 1, eb, 101)
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[1,-1]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0,1]'
    type: qpsk
  states: {}
- name: corr_calc
  id: variable
  parameters:
    value: corr_thresh/(corr_max*corr_max)
  states: {}
- name: corr_max
  id: variable
  parameters:
    value: numpy.abs(numpy.dot(modulated_sync_word,numpy.conj(modulated_sync_word)))
  states: {}
- name: corr_thresh
  id: variable_qtgui_range
  parameters:
    label: Absolute Corr Thresh (Mag Sq)
    orient: Qt.Horizontal
    start: '0.1'
    step: '1.0'
    stop: 5e6
    value: 3e6
  states: {}
- name: data
  id: variable
  parameters:
    value: '[0]*4+[random.getrandbits(8) for i in range(payload_size)]'
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: gap
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: interferer
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,1,1,1
    label: interferer
    orient: Qt.Horizontal
    start: '0'
    step: '0.005'
    stop: '10'
    value: '0'
  states: {}
- name: intf_angle
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,1
    label: Interferer Angle
    orient: Qt.Horizontal
    start: '-90'
    step: '.1'
    stop: '90'
    value: '75'
  states: {}
- name: matched_filter
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1, eb, int(11*sps*nfilts))
  states: {}
- name: modulated_sync_word
  id: variable
  parameters:
    comment: |-
      Note that the modulated sync word
      as generated by Modulate Vector
      block has some filtering transients.

      Offset to the beginning of the 
      actual preamble
    value: modulated_sync_word_pre[86:(512+86)]
  states: {}
- name: modulated_sync_word_pre
  id: variable_modulate_vector
  parameters:
    data: ' preamble+preamble'
    mod: rxmod
    taps: '[1]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Noise
    orient: Qt.Horizontal
    start: '0'
    step: '0.005'
    stop: '10'
    value: '0'
    widget: slider
  states: {state: disabled}
- name: payload_size
  id: variable
  parameters:
    value: '992'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0x27,0x2F,0x18,0x5D,0x5B,0x2A,0x3F,0x71,0x63,0x3C,0x17,0x0C,0x0A,0x41,0xD6,0x1F,0x4C,0x23,0x65,0x68,0xED,0x1C,0x77,0xA7,0x0E,0x0A,0x9E,0x47,0x82,0xA4,0x57,0x24,]'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), eb, 5*sps*nfilts)
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(constel, False, sps, True, eb, False, False)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbols_per_byte
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_fastnoise_source_x_0_0
  id: analog_fastnoise_source_x
  parameters:
    amp: interferer
    comment: |-
      Noise only interferer.
      MMSE calculation knows 
      nothing about the 
      interferer
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: bfutils_calc_array_weights_0
  id: bfutils_calc_array_weights
  parameters:
    bf_mode: bfutils.MMSE
    num_elements: '4'
    preamble: modulated_sync_word
  states: {}
- name: bfutils_polar_plot_0
  id: bfutils_polar_plot
  parameters:
    autoscale: 'True'
    gui_hint: 0,1,4,1
    log_scale: 'True'
    plot_depth: '70.0'
  states: {}
- name: bfutils_preamble_to_pdu_0
  id: bfutils_preamble_to_pdu
  parameters:
    corr_tag: '"corr_est"'
    data_length: len(modulated_sync_word)
    num_elements: '4'
  states: {}
- name: bfutils_ula_sim_0
  id: bfutils_ula_sim
  parameters:
    angle_degrees: angle
    log_response: 'True'
    num_elements: '4'
    sep_lambda: '0.5'
  states: {}
- name: bfutils_ula_sim_1
  id: bfutils_ula_sim
  parameters:
    angle_degrees: intf_angle
    log_response: 'True'
    num_elements: '4'
    sep_lambda: '0.5'
  states: {}
- name: bfutils_weights_to_matrix_a_0
  id: bfutils_weights_to_matrix_a
  parameters: {}
  states: {}
- name: bfutils_weights_to_plot_0
  id: bfutils_weights_to_plot
  parameters:
    log_response: 'True'
    num_elements: '4'
    sep_lambda: '0.5'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: '4'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: len(modulated_sync_word_pre)
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: len(modulated_sync_word)
    num_ports: '3'
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: ((1+0j, 0+0j, 0+0j, 0+0j),)
    comment: |-
      Apply the weights to
       just the preamble 
      to beamform down 
      to a single stream
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '86'
    type: complex
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: ((len(preamble)+len(data))*symbols_per_byte*sps, gap-(len(preamble)+len(data))*symbols_per_byte*sps)
    type: complex
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*10
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: modulated_sync_word_pre
    vlen: len(modulated_sync_word_pre)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: preamble+data
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'False'
    excess_bw: eb
    samples_per_symbol: sps
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: '1'
    sps: sps
    symbols: modulated_sync_word
    threshold: corr_calc
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0,4,1
    label1: Single Stream
    label2: Beamformed
    nconnections: '2'
    size: '100'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Correlation Squared Magnitude
    size: '80000'
    srate: '1'
    type: float
    yunit: Squared Magnitude
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color3: black
    color4: cyan
    color5: magenta
    color6: yellow
    color7: dark red
    color8: dark green
    gui_hint: 4,0,4,1
    nconnections: '4'
    size: '80000'
    srate: '1'
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 8,0,1,2
    label1: Single Antenna - I
    label2: Single Antenna - Q
    label3: Beamformed - I
    label4: Beamformed - Q
    name: Preamble Symbols
    nconnections: '2'
    size: '300'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 9,0,1,2
    label1: After Beamforming
    label2: Single Antenna
    name: Preamble Symbols
    nconnections: '4'
    size: '300'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    gui_hint: 12,0,1,1
    name: Modulated Sync Word
    vlen: len(modulated_sync_word_pre)
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}

connections:
- [analog_fastnoise_source_x_0_0, '0', bfutils_ula_sim_1, '0']
- [bfutils_calc_array_weights_0, weights, bfutils_weights_to_matrix_a_0, weights]
- [bfutils_calc_array_weights_0, weights, bfutils_weights_to_plot_0, weights]
- [bfutils_preamble_to_pdu_0, pdus, bfutils_calc_array_weights_0, pdus]
- [bfutils_preamble_to_pdu_0, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [bfutils_ula_sim_0, '0', blocks_add_xx_0, '0']
- [bfutils_ula_sim_1, '0', blocks_add_xx_0, '1']
- [bfutils_weights_to_matrix_a_0, A, blocks_multiply_matrix_xx_0, set_A]
- [bfutils_weights_to_plot_0, plot, bfutils_polar_plot_0, plot]
- [blocks_add_xx_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_deinterleave_0, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_deinterleave_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_deinterleave_0, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_deinterleave_0, '1', blocks_multiply_matrix_xx_0, '1']
- [blocks_deinterleave_0, '1', blocks_null_sink_0, '0']
- [blocks_deinterleave_0, '1', qtgui_time_sink_x_2_0, '1']
- [blocks_deinterleave_0, '2', blocks_multiply_matrix_xx_0, '2']
- [blocks_deinterleave_0, '2', blocks_null_sink_0, '1']
- [blocks_deinterleave_0, '2', qtgui_time_sink_x_2_0, '2']
- [blocks_deinterleave_0, '3', blocks_multiply_matrix_xx_0, '3']
- [blocks_deinterleave_0, '3', blocks_null_sink_0, '2']
- [blocks_deinterleave_0, '3', qtgui_time_sink_x_2_0, '3']
- [blocks_delay_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_delay_0, '1', blocks_streams_to_vector_0, '2']
- [blocks_delay_0, '1', qtgui_time_sink_x_1, '2']
- [blocks_delay_0, '2', blocks_streams_to_vector_0, '3']
- [blocks_delay_0, '2', qtgui_time_sink_x_1, '3']
- [blocks_multiply_matrix_xx_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [blocks_null_source_0_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_deinterleave_0, '0']
- [blocks_skiphead_0, '0', blocks_stream_mux_0_0, '0']
- [blocks_stream_mux_0_0, '0', blocks_throttle_0, '0']
- [blocks_streams_to_vector_0, '0', bfutils_preamble_to_pdu_0, '0']
- [blocks_throttle_0, '0', bfutils_ula_sim_0, '0']
- [blocks_vector_source_x_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_vector_source_x_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_to_streams_0, '0', digital_corr_est_cc_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_delay_0, '0']
- [blocks_vector_to_streams_0, '2', blocks_delay_0, '1']
- [blocks_vector_to_streams_0, '3', blocks_delay_0, '2']
- [digital_constellation_modulator_0, '0', blocks_skiphead_0, '0']
- [digital_corr_est_cc_0, '0', blocks_streams_to_vector_0, '0']
- [digital_corr_est_cc_0, '0', qtgui_time_sink_x_1, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_mag_squared_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_time_sink_x_2, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_const_sink_x_0, '1']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_time_sink_x_2, '1']

metadata:
  file_format: 1
